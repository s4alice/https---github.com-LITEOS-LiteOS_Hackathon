# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; IR_SENSOR
  ICCARM.CCIncludePath2: C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\platform\bsp\sample\Libraries\CMSIS\Include; C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\platform\bsp\sample\Libraries\CMSIS\Device\ST\STM32F4xx\Include; C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\platform\bsp\sample\Libraries\STM32F4x7_ETH_Driver\inc; C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\platform\bsp\sample\Libraries\STM32F4xx_StdPeriph_Driver\inc; C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\kernel\include; C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\kernel\base\include; C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\platform\cpu\arm\cortex-m4; C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\platform\bsp\sample\config; C:\Users\Admin\Desktop\LiteOS\Huawei_LiteOS\kernel\base\ipc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.bin
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: Huawei_LiteOS_cortexMF411.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/kernel/base
    ../../../../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../../../Huawei_LiteOS/kernel/base/misc/: los_misc.c
    ../../../../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/platform/bsp
    ../../../../Huawei_LiteOS/platform/bsp/sample/config/: IR_Task.c KeyBoard_Task.c Led_Task.c los_config.c Manager_Task.c Motor_Task.c RTC_Task.c Uart_Task.c WiFi_Task.c
  group Huawei_LiteOS/platform/cpu
    ../../../../Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_dispatch.s los_hw.c los_hw_tick.c los_hwi.c los_vendor.s
  group Huawei_LiteOS/platform/ST_F4xx
    ../../../../Huawei_LiteOS/platform/bsp/sample/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_usart.c
    ../../../../Huawei_LiteOS/platform/bsp/sample/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
